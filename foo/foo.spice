* SPICE netlist generated by Yosys 0.9 (git sha1 UNKNOWN, clang 10.0.1 -fPIC -Os)

.SUBCKT foo a b c o
X0 c 1 NOT
X1 a b 2 NAND
X2 1 2 3 NAND
V0 4 a DC 0
V1 5 b DC 0
V2 6 c DC 0
V3 o 3 DC 0
.ENDS foo

************************
* end of SPICE netlist *
************************
